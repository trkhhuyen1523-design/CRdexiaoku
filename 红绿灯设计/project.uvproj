# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay1ms.c Delay1ms.h DS1302.c DS1302.h key.c key.h LCD1602.c LCD1602.h MatrixKey.c MatrixKey.h MatrixLED.c MatrixLED.h Nixie.c Nixie.h Timer0.c Timer0.h UART.c UART.h Timer1.c Timer1.h
